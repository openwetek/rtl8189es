## rtl8189ES/Kconfig
```kconfig
config RTL8189ES
	tristate "Realtek 8189E SDIO WiFi"
	depends on AM_WIFI_SD_MMC
	---help---
	  Help message of RTL8189ES
```
